* SPICE3 file created from maj.ext - technology: scmos
.include MOSIS_TSMC_025um.spice
.option scale=1u

M1000 a_n11_18# b a_20_18# Vdd CMOSP w=40 l=2
+  ad=420 pd=192 as=240 ps=92
M1001 gnd b a_n11_n14# gnd CMOSN w=8 l=2
+  ad=88 pd=54 as=88 ps=54
M1002 Vdd b a_n11_18# Vdd CMOSP w=20 l=2
+  ad=120 pd=52 as=0 ps=0
M1003 a_n11_18# c Vdd Vdd CMOSP w=20 l=2
+  ad=0 pd=0 as=0 ps=0
M1004 a_20_n14# c out gnd CMOSN w=8 l=2
+  ad=48 pd=28 as=48 ps=28
M1005 out a a_n11_n14# gnd CMOSN w=8 l=2
+  ad=0 pd=0 as=0 ps=0
M1006 out a a_n11_18# Vdd CMOSP w=20 l=2
+  ad=220 pd=92 as=0 ps=0
M1007 a_n11_n14# c gnd gnd CMOSN w=8 l=2
+  ad=0 pd=0 as=0 ps=0
M1008 gnd b a_20_n14# gnd CMOSN w=8 l=2
+  ad=0 pd=0 as=0 ps=0
M1009 a_20_18# c out Vdd CMOSP w=40 l=2
+  ad=0 pd=0 as=0 ps=0
C0 b gnd 3.58fF
C1 Vdd a_n11_18# 4.14fF
C2 gnd c 3.82fF
C3 out 0 4.75fF
C4 a_n11_18# 0 3.76fF
C5 a 0 5.66fF
C6 c 0 11.32fF
C7 b 0 12.42fF

Vvdd Vdd 0 2.5V DC
Va a 0 PULSE(0V 2.5V 0 1ns 1ns 80ns 160ns)
Vb b 0 0 PULSE(0V 2.5V 0 1ns 1ns 40ns 80ns)
Vc c 0 0 PULSE(0V 2.5V 0 1ns 1ns 20ns 40ns)

.control
tran 1ns 160ns
run
plot V(a) V(b) V(c) V(out) title "F_maj All States Plot"
alter Va=0V
alter Vb=0V
alter Vc=0V

op

print V(a) V(b) V(c) V(out)
alter Vc=2.5V
op
print V(a) V(b) V(c) V(out)
alter Vc=0v
alter Vb=2.5V
op
print V(a) V(b) V(c) V(out)
alter Vc=2.5v
op
print V(a) V(b) V(c) V(out)
alter Vc=0v
alter Vb=0V
alter Va=2.5V
op
print V(a) V(b) V(c) V(out)
alter Vc=2.5v
op
print V(a) V(b) V(c) V(out)
alter Vc=0v
alter Vb=2.5v
op
print V(a) V(b) V(c) V(out)
alter Vc = 2.5
op
print V(a) V(b) V(c) V(out)

.endc

.end
